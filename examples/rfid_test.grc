options:
  parameters:
    generate_options: qt_gui
    id: rfid_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: adc_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: ampl
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: dac_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '5'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '910000000'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/xin/gr-rfid/misc/data/matched_filter
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/xin/gr-rfid/misc/data/source
    type: complex
  states: {}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: /home/xin/gr-rfid/misc/data/gate
    type: complex
  states: {}
- name: blocks_file_sink_2_0
  id: blocks_file_sink
  parameters:
    file: /home/xin/gr-rfid/misc/data/decoder
    type: complex
  states: {}
- name: blocks_file_sink_2_0_0
  id: blocks_file_sink
  parameters:
    file: /home/xin/gr-rfid/misc/data/reader
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: ampl
    type: float
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: decim
    taps: '[1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1]'
    type: ccc
  states: {}
- name: rfid_gate_0
  id: rfid_gate
  parameters:
    sample_rate: adc_rate//decim
  states: {}
- name: rfid_reader_0
  id: rfid_reader
  parameters:
    dac_rate: dac_rate
    sample_rate: adc_rate//decim
  states: {}
- name: rfid_tag_decoder_0
  id: rfid_tag_decoder
  parameters:
    sample_rate: adc_rate//decim
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: dac_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: adc_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '1']
- [fir_filter_xxx_0, '0', blocks_file_sink_0, '0']
- [fir_filter_xxx_0, '0', rfid_gate_0, '0']
- [rfid_gate_0, '0', blocks_file_sink_2, '0']
- [rfid_gate_0, '0', rfid_tag_decoder_0, '0']
- [rfid_reader_0, '0', blocks_file_sink_2_0_0, '0']
- [rfid_reader_0, '0', blocks_multiply_const_vxx_0, '0']
- [rfid_tag_decoder_0, '0', rfid_reader_0, '0']
- [rfid_tag_decoder_0, '1', blocks_file_sink_2_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_1, '0']
- [uhd_usrp_source_0, '0', fir_filter_xxx_0, '0']

metadata:
  file_format: 1
